# Keil uVision project Project_ns.uvprojx, settings and files
target NUCLEO-L552ZE-Q_ns (6120000::V6.12::.\ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9
  cpu: IROM(0x08040000-0x807FFFF) IRAM(0x20018000-0x2002FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project_ns +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L552xx,USE_HAL_DRIVER
  c include: ../NonSecure/Inc;../Secure_nsclib;../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;;../../../../../Drivers/BSP/STM32L5xx_Nucleo
  asm define: STM32L552xx
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20018000 size 0x18000
  scatter file: stm32l552xe_flash_ns.sct
  link misc: ./../Secure_nsclib/secure_nsclib.o
  group Drivers/BSP/STM32L5xx_Nucleo
    ../../../../../Drivers/BSP/STM32L5xx_Nucleo/: stm32l5xx_nucleo.c stm32l5xx_nucleo_usbpd_pwr.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal_comp.c stm32l5xx_hal_cortex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_dac.c stm32l5xx_hal_dac_ex.c stm32l5xx_hal_dfsdm.c stm32l5xx_hal_dfsdm_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_fdcan.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_irda.c stm32l5xx_hal_iwdg.c stm32l5xx_hal_lptim.c stm32l5xx_hal_mmc.c stm32l5xx_hal_mmc_ex.c stm32l5xx_hal_nand.c stm32l5xx_hal_nor.c stm32l5xx_hal_opamp.c stm32l5xx_hal_opamp_ex.c stm32l5xx_hal_ospi.c stm32l5xx_hal_pka.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rng.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_sai.c stm32l5xx_hal_sai_ex.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c stm32l5xx_hal_smartcard.c stm32l5xx_hal_smartcard_ex.c stm32l5xx_hal_smbus.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_sram.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_tsc.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_usart.c stm32l5xx_hal_usart_ex.c stm32l5xx_hal_wwdg.c stm32l5xx_ll_fmc.c stm32l5xx_ll_sdmmc.c stm32l5xx_hal_cryp.c stm32l5xx_hal_cryp_ex.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_hash.c stm32l5xx_hal_hash_ex.c stm32l5xx_hal_pcd.c stm32l5xx_hal_pcd_ex.c stm32l5xx_ll_usb.c stm32l5xx_ll_ucpd.c
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32l5xx_ns.c
  group Example/MDK-ARM
    ./: startup_stm32l552xx.s
  group Example/User
    ../NonSecure/Src/: main.c stm32l5xx_hal_msp.c stm32l5xx_it.c
  group Doc
    ../: readme.txt
