# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-L552ZE-Q_TIM_BreakAndDeadtime (ARM-ADS)
  device: STM32L552ZETxQ STMicroelectronics
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2002FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L552xx,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc
  library: MicroLIB
  scatter file: stm32l552xe_flash.sct
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l5xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32l552xx.s
  group Drivers/STM32L5xx_LL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_ll_utils.c stm32l5xx_ll_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
software components: CMSIS:CORE 4.3.0
