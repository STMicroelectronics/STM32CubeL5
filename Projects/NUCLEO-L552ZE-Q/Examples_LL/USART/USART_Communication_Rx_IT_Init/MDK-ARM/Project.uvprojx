# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-L552ZE-Q_USART_Communication_Rx_IT_Init (6120000::V6.12::.\ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L552xx,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l5xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32l552xx.s
  group Drivers/STM32L5xx_LL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_ll_rcc.c stm32l5xx_ll_usart.c stm32l5xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
software components: CMSIS:CORE 5.2.0
