# IAR project USART_SyncCommunication_FullDuplex_DMA_Init.ewp, settings and files
configuration USART_SyncCommunication_FullDuplex_DMA_Init (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; MSI_VALUE=4000000; HSI_VALUE=16000000; LSI_VALUE=32000; STM32L552xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USART_SyncCommunication_FullDuplex_DMA_Init.hex
  ILINK.IlinkOutputFile: USART_SyncCommunication_FullDuplex_DMA_Init.out
  ILINK.IlinkIcfFile: stm32l552xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l552xx.s
  group Application/User
    ../Src/: main.c stm32l5xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_ll_exti.c stm32l5xx_ll_utils.c stm32l5xx_ll_gpio.c stm32l5xx_ll_dma.c stm32l5xx_ll_pwr.c stm32l5xx_ll_spi.c stm32l5xx_ll_usart.c stm32l5xx_ll_rcc.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
