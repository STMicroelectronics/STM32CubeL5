# Keil uVision project USART_WakeUpFromStop1_Init.uvprojx, settings and files
target USART_WakeUpFromStop1_Init (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: USART_WakeUpFromStop1_Init +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=4000000,HSI_VALUE=16000000,LSI_VALUE=32000,STM32L552xx
  c include: ../Inc;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: stm32l552xe_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32l552xx.s
  group Application/User
    ../Src/: main.c stm32l5xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_ll_exti.c stm32l5xx_ll_utils.c stm32l5xx_ll_gpio.c stm32l5xx_ll_pwr.c stm32l5xx_ll_usart.c stm32l5xx_ll_rcc.c stm32l5xx_ll_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
software components: CMSIS:CORE 4.3.0
