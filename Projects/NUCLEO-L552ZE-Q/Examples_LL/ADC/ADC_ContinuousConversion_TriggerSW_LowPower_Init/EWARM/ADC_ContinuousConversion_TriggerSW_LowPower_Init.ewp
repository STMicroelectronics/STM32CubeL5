# IAR project ADC_ContinuousConversion_TriggerSW_LowPower_Init.ewp, settings and files
configuration ADC_ContinuousConversion_TriggerSW_LowPower_Init (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; MSI_VALUE=4000000; EXTERNALSAI1_CLOCK_VALUE=48000; EXTERNALSAI2_CLOCK_VALUE=48000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; INSTRUCTION_CACHE_ENABLE=0; DATA_CACHE_ENABLE=0; STM32L552xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_ContinuousConversion_TriggerSW_LowPower_Init.hex
  ILINK.IlinkOutputFile: ADC_ContinuousConversion_TriggerSW_LowPower_Init.out
  ILINK.IlinkIcfFile: stm32l552xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l552xx.s
  group Application/User
    ../Src/: main.c stm32l5xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_ll_exti.c stm32l5xx_ll_utils.c stm32l5xx_ll_gpio.c stm32l5xx_ll_adc.c stm32l5xx_ll_dma.c stm32l5xx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
