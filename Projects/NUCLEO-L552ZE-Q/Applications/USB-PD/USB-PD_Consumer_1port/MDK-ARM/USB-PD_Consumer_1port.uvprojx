# Keil uVision project USB-PD_Consumer_1port.uvprojx, settings and files
target USB-PD_Consumer_1port (6190000::V6.19::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: USB-PD_Consumer_1port +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USBPD_PORT_COUNT=1,USBPDCORE_LIB_PD3_FULL,_SNK,_TRACE,_GUI_INTERFACE,USE_HAL_DRIVER,STM32L552xx,_RTOS
  c include: ../Inc;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/GUI_INTERFACE;../../../../../../Utilities/TRACER_EMB;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc;../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32L5XX/inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/CMSIS/Include;..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include;C:/Users/gucadier/STM32Cube/Repository/STM32Cube_FW_L5_V1.4.0RC1/Drivers/STM32L5xx_HAL_Driver/Inc;C:/Users/gucadier/STM32Cube/Repository/STM32Cube_FW_L5_V1.4.0RC1/Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;C:/Users/gucadier/STM32Cube/Repository/STM32Cube_FW_L5_V1.4.0RC1/Utilities/GUI_INTERFACE;C:/Users/gucadier/STM32Cube/Repository/STM32Cube_FW_L5_V1.4.0RC1/Utilities/TRACER_EMB;C:/Users/gucadier/STM32Cube/Repository/STM32Cube_FW_L5_V1.4.0RC1/Middlewares/Third_Party/FreeRTOS/Source/include;C:/Users/gucadier/STM32Cube/Repository/STM32Cube_FW_L5_V1.4.0RC1/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;C:/Users/gucadier/STM32Cube/Repository/STM32Cube_FW_L5_V1.4.0RC1/Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure;C:/Users/gucadier/STM32Cube/Repository/STM32Cube_FW_L5_V1.4.0RC1/Middlewares/ST/STM32_USBPD_Library/Core/inc;C:/Users/gucadier/STM32Cube/Repository/STM32Cube_FW_L5_V1.4.0RC1/Middlewares/ST/STM32_USBPD_Library/Devices/STM32L5XX/inc;C:/Users/gucadier/STM32Cube/Repository/STM32Cube_FW_L5_V1.4.0RC1/Drivers/CMSIS/Device/ST/STM32L5xx/Include;C:/Users/gucadier/STM32Cube/Repository/STM32Cube_FW_L5_V1.4.0RC1/Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: stm32l552xe_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32l552xx.s
  group Application/User
    ../Src/: main.c app_freertos.c usbpd.c usbpd_dpm_user.c usbpd_pwr_user.c usbpd_pwr_if.c usbpd_vdm_user.c usbpd_dpm_core.c stm32l5xx_it.c stm32l5xx_hal_msp.c stm32l5xx_hal_timebase_tim.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_ll_exti.c stm32l5xx_ll_utils.c stm32l5xx_ll_gpio.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_icache.c stm32l5xx_ll_dma.c stm32l5xx_ll_lpuart.c stm32l5xx_ll_rcc.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_ll_usart.c stm32l5xx_ll_ucpd.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
  group Middlewares/USBPD
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM33_Keil.lib
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32L5XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group Utilities
    ../../../../../../Utilities/GUI_INTERFACE/: bsp_gui.c gui_api.c data_struct_tlv.c
    ../../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
software components: CMSIS:CORE 4.3.0
