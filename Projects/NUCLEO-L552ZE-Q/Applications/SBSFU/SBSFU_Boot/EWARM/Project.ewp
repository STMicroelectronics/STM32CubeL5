# IAR project Project.ewp, settings and files
configuration NUCLEO-L552ZE-Q_SBSFU_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32L552xx; USE_HAL_DRIVER; NDEBUG; TFM_DEV_MODE; MCUBOOT_TARGET_CONFIG=<flash_layout.h>; MBEDTLS_CONFIG_FILE=<config-boot.h>; MCUBOOT_DOUBLE_SIGN_VERIF; DEFAULT_UART_BAUDRATE=115200; BL2; Image$$=; Load$$LR$$=; $$ZI$$Base=$$Base; $$ZI$$Limit=$$Limit; $$RO$$Base=$$Base; $$RO$$Limit=$$Limit; _DATA$$RW$$Base=_DATA$$Base; _DATA$$RW$$Limit=_DATA$$Limit; _DATA$$ZI$$Base=_DATA$$Base; _DATA$$ZI$$Limit=_DATA$$Limit; _STACK$$ZI$$Base=_STACK$$Base; _STACK$$ZI$$Limit=_STACK$$Limit
  ICCARM.IExtraOptions: -DNO_TYPEOF
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L5xx_Nucleo; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\common; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\ext\mcuboot\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\src; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext\tinycrypt\lib\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include; ..\..\Linker
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild.cmd "$PROJ_DIR$"
  postbuild: cmd /C "cmd /C postbuild.bat"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: bl2.icf.i
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_icache.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rng.c stm32l5xx_hal_rng_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_hash.c stm32l5xx_hal_hash_ex.c
  group Middlewares/mcuboot
    ../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c tlv.c swap_scratch.c swap_move.c swap_misc.c image_ec.c image_ec256.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_validate.c caps.c loader.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/: bl2_main.c flash_map_extended.c flash_map_legacy.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/src/: flash_map.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common/: uart_stdout.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: asn1parse.c bignum.c ctr_drbg.c sha256.c memory_buffer_alloc.c platform.c platform_util.c ecdsa.c ecdh.c ecp.c ecp_curves.c aes.c md.c hkdf.c cipher.c bignum_core.c constant_time.c
  group Application/User
    ../Src/: mpu_armv8m_drv.c boot_hal.c low_level_flash.c low_level_com.c low_level_device.c bl2_nv_services.c low_level_security.c low_level_rng.c keys.c keys_map.c sha256_alt.c system_stm32l5xx.c
  group Application/EWARM
    ./: startup_stm32l552xx.s
  group Doc
    ../: readme.txt
