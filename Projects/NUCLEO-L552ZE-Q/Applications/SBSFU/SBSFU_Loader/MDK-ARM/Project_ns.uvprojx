# Keil uVision project Project_ns.uvprojx, settings and files
target NUCLEO-L552ZE-Q_SBSFU_Loader (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L552VETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  AfterMake: postbuild.bat  "nonsecure"
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L552xx,USE_HAL_DRIVER,LOCAL_LOADER_CONFIG,BL2
  c include: ../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L5xx_Nucleo;../NonSecure/Inc;../../../../../../Middlewares/Third_Party/mcuboot/test/suites/crypto;../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/driver;../../Linker;../Secure_nsclib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: stm32l552xe_flash_ns.sct
  link misc: --predefine=-DBL2
--predefine=-I../../Linker
../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ./: startup_stm32l552xx.s
  group Application/User
    ../NonSecure/Src/: com.c common.c fw_update_app.c low_level_device.c low_level_flash.c main.c system_stm32l5xx.c tick.c ymodem.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
