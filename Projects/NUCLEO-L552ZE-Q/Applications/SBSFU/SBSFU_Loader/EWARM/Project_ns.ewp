# IAR project Project_ns.ewp, settings and files
configuration NUCLEO-L552ZE-Q_SBSFU_Loader (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32L552xx; USE_HAL_DRIVER; LOCAL_LOADER_CONFIG; BL2
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L5xx_Nucleo; ..\NonSecure\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver; ..\..\Linker; ..\Secure_nsclib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_ns.cmd "$PROJ_DIR$"
  postbuild: cmd /C "cmd /C postbuild.bat  "nonsecure""
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: flash_ns.icf.i
  ILINK.IlinkAdditionalLibs: ../Secure_nsclib/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l552xx.s
  group Application/User
    ../NonSecure/Src/: com.c common.c fw_update_app.c low_level_device.c low_level_flash.c main.c system_stm32l5xx.c tick.c ymodem.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
