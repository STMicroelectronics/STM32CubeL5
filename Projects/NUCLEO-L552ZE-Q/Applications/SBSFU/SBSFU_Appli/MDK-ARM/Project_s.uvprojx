# Keil uVision project Project_s.uvprojx, settings and files
target NUCLEO-L552ZE-Q_SBSFU_Appli_Secure (6100001::V6.10.1::.\ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  BeforeMake: $J\..\bin\armclang --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -DBL2 -DMCUBOOT_IMAGE_NUMBER=2 -I..\..\Linker  ..\..\SBSFU_Boot\Src\image_macros_to_preprocess_s.c -o image_macros_preprocessed_s.c
  BeforeMake: $J\..\bin\armclang  --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -DBL2 -DMCUBOOT_IMAGE_NUMBER=2 -I..\..\Linker  ..\..\SBSFU_Boot\Src\image_macros_to_preprocess_ns.c -o image_macros_preprocessed_ns.c
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  AfterMake: postbuild.bat . "1.0.0" "secure"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L552xx,USE_HAL_DRIVER,USE_STM32L5XX_NUCLEO_144, BL2,MCUBOOT_IMAGE_NUMBER=2
  c include: ../Secure_nsclib;../Secure/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../Linker
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: stm32l552xe_flash_s.sct
  link misc: --predefine=-I../../Linker
--predefine=-DBL2
--predefine=-DMCUBOOT_IMAGE_NUMBER=2
--import_cmse_lib_out=.\..\Secure_nsclib\secure_nsclib.o
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Secure/Src/: system_stm32l5xx_s.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_exti.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l552xx.s
  group Example/User
    ../Secure/Src/: main.c secure_nsc.c stm32l5xx_hal_msp.c stm32l5xx_it.c
software components: CMSIS:CORE 5.2.0
