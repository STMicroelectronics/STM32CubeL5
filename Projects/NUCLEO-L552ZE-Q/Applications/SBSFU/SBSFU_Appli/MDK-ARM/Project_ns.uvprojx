# Keil uVision project Project_ns.uvprojx, settings and files
target NUCLEO-L552ZE-Q_SBSFU_Appli_NonSecure (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L552ZETx STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.1.1
  cpu: IROM(0x08040000-0x807FFFF) IRAM(0x20018000-0x2002FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  AfterMake: postbuild.bat .  "1.0.0" "nonsecure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L552xx,USE_HAL_DRIVER,BL2
  c include: ../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L5xx_Nucleo;../NonSecure/Inc;../Secure_nsclib;../../Linker;../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/driver
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20018000 size 0x18000
  scatter file: stm32l552xe_flash_ns.sct
  link misc: --predefine=-I../../Linker
--predefine=-DBL2
--predefine=-DTFM_PSA_API
../Secure_nsclib/secure_nsclib.o
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32l5xx_ns.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l552xx.s
  group Example/User
    ../NonSecure/Src/: main.c stm32l5xx_it.c com.c common.c fw_update_app.c mpu_armv8m_drv.c test_protections.c ymodem.c low_level_flash.c low_level_device.c
software components: CMSIS:CORE 4.3.0
