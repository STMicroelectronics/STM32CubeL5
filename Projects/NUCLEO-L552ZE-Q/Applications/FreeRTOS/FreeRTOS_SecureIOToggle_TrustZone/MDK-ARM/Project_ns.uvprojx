# Keil uVision project Project_ns.uvprojx, settings and files
target NUCLEO-L552ZE-Q_FreeRTOS_SecureIOToggle_TrustZone (6120000::V6.12::.\ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project_ns +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L552xx,USE_HAL_DRIVER
  c include: ..;../Secure_nsclib;../NonSecure/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L5xx_Nucleo;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../Common/OS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/secure;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/non_secure
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20018000 size 0x18000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: .\stm32l552xe_flash_ns.sct
  link misc: ../Secure_nsclib/secure_nsclib.o
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L5xx_Nucleo/: stm32l5xx_nucleo.c
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32l5xx_ns.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l552xx.s
  group Example/User
    ../NonSecure/Src/: main.c stm32l5xx_hal_msp.c stm32l5xx_hal_timebase_tim.c stm32l5xx_it.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/non_secure/: port.c portasm.c
software components: CMSIS:CORE 5.2.0
