# Keil uVision project FreeRTOS_SecureIOToggle_TrustZone_NS.uvprojx, settings and files
target FreeRTOS_SecureIOToggle_TrustZone_NS (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.11
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: FreeRTOS_SecureIOToggle_TrustZone_NS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L552xx
  c include: ../NonSecure/Inc;../Secure_nsclib;../../../../../../Drivers/BSP/STM32L5xx_Nucleo;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/non_secure;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/secure;../../../../../../Drivers/CMSIS/Include
  asm include: ..\NonSecure\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: stm32l552xe_flash_ns.sct
  link misc: ../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ./: startup_stm32l552xx.s
  group Application/User/NonSecure
    ../NonSecure/Src/: main.c app_freertos.c stm32l5xx_it.c stm32l5xx_hal_msp.c stm32l5xx_hal_timebase_tim.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L5xx_Nucleo/: stm32l5xx_nucleo.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal_exti.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_icache.c
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32l5xx_ns.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/non_secure/: port.c portasm.c
software components: CMSIS:CORE 5.3.0
