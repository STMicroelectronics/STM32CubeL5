<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DMA_MemToMem_TrustZone_S.ewp</path>
  </project><project>
    <path>$WS_DIR$\DMA_MemToMem_TrustZone_NS.ewp</path>
  </project>
  <batchBuild />
</workspace>
