<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HASH_SHA1_DMA_TrustZone_S.ewp</path>
  </project><project>
    <path>$WS_DIR$\HASH_SHA1_DMA_TrustZone_NS.ewp</path>
  </project>
  <batchBuild />
</workspace>
