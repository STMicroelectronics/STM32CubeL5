# IAR project HASH_SHA1_DMA_TrustZone_S.ewp, settings and files
configuration HASH_SHA1_DMA_TrustZone_S (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L552xx
  ICCARM.CCIncludePath2: ../Secure/Inc; ../Secure_nsclib; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32L5xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HASH_SHA1_DMA_TrustZone_S.hex
  ILINK.IlinkOutputFile: HASH_SHA1_DMA_TrustZone_S.out
  ILINK.IlinkIcfFile: stm32l552xe_flash_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l552xx.s
  group Application/User/Secure
    ../Secure/Src/: main.c secure_nsc.c stm32l5xx_hal_msp.c stm32l5xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L5xx_Nucleo/: stm32l5xx_nucleo.c
  group Drivers/CMSIS
    ../Secure/Src/: system_stm32l5xx_s.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_hash.c stm32l5xx_hal_hash_ex.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c
