# IAR project Project_s.ewp, settings and files
configuration NUCLEO-L552ZE-Q_HASH_SHA1_DMA (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32L552xx; USE_HAL_DRIVER; USE_STM32L5XX_NUCLEO_144
  ICCARM.CCIncludePath2: ..\Secure_nsclib; ..\Secure\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L5xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_s.srec
  ILINK.IlinkOutputFile: project_s.out
  ILINK.IlinkIcfFile: stm32l552xe_flash_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L5xx_Nucleo/: stm32l5xx_nucleo.c
  group Drivers/CMSIS
    ../Secure/Src/: system_stm32l5xx_s.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_hash.c stm32l5xx_hal_hash_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c
  group Example/EWARM
    ./: startup_stm32l552xx.s
  group Example/User
    ../Secure/Src/: main.c secure_nsc.c stm32l5xx_hal_msp.c stm32l5xx_it.c
