# Keil uVision project HASH_SHA1_DMA_TrustZone_S.uvprojx, settings and files
target HASH_SHA1_DMA_TrustZone_S (ARM-ADS)
  device: STM32L552ZETxQ STMicroelectronics
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: HASH_SHA1_DMA_TrustZone_S +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L552xx
  c include: ../Secure/Inc;../Secure_nsclib;../../../../../../Drivers/BSP/STM32L5xx_Nucleo;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  scatter file: stm32l552xe_flash_s.sct
  link misc: --import_cmse_lib_out=..\Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ./: startup_stm32l552xx.s
  group Application/User/Secure
    ../Secure/Src/: main.c stm32l5xx_it.c stm32l5xx_hal_msp.c secure_nsc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L5xx_Nucleo/: stm32l5xx_nucleo.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal_gtzc.c stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_icache.c stm32l5xx_hal_hash.c stm32l5xx_hal_hash_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Secure/Src/: system_stm32l5xx_s.c
software components: CMSIS:CORE 4.3.0
