<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HASH_SHA224SHA256_DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>
