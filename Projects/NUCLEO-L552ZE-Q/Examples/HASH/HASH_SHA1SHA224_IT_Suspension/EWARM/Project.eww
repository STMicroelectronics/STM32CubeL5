<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HASH_SHA1SHA224_IT_Suspension.ewp</path>
  </project>
  <batchBuild />
</workspace>
