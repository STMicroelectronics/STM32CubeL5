# IAR project MenuLauncher.ewp, settings and files
configuration STM32L562E-DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562QE ST STM32L562QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: ST; USE_HAL_DRIVER; STM32L562xx; USE_BPP=16; USE_STM32L562E_DISCO
  ICCARM.IExtraOptions: --diag_warning Pa082; --diag_suppress Pa082; --diag_warning Pe2464; --diag_suppress Pe2464
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\..\Config; ..\TouchGFX\gui\include; ..\TouchGFX\target\; ..\TouchGFX\generated\fonts\include; ..\TouchGFX\generated\images\include; ..\TouchGFX\generated\texts\include; ..\TouchGFX\generated\gui_generated\include; ..\..\Middlewares_Addons\touchgfx\framework\include; ..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\RTOS2\Include; ..\..\..\..\..\Drivers\BSP\STM32L562E-DK; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM33_NTZ\non_secure
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ST; STM32L562xx; USE_BPP=16; CORE_CM33; USE_STM32L562E_DISCO; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\Core\Inc; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: MenuLauncher-STM32L562E-DK.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08000000
  ILINK.IlinkIcfFile: stm32l562xe_flash.icf
  ILINK.IlinkExtraOptions: --diag_warning Lc059; --diag_suppress Lc059
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Source/Templates/iar/: startup_stm32l562xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c main.cpp stm32l5xx_hal_msp.c stm32l5xx_hal_timebase_tim.c stm32l5xx_it.c
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_NotoSans_Regular_13_4bpp_0.cpp Font_NotoSans_Regular_20_4bpp_0.cpp Font_NotoSans_Regular_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_NotoSans_Regular_13_4bpp.cpp Kerning_NotoSans_Regular_20_4bpp.cpp Kerning_NotoSans_Regular_40_4bpp.cpp Table_NotoSans_Regular_13_4bpp.cpp Table_NotoSans_Regular_20_4bpp.cpp Table_NotoSans_Regular_40_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../TouchGFX/generated/gui_generated/src/containers/: MenuContainerBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/menu_screen
    ../TouchGFX/generated/gui_generated/src/menu_screen/: MenuViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/popup_screen
    ../TouchGFX/generated/gui_generated/src/popup_screen/: PopUpViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/splash_screen
    ../TouchGFX/generated/gui_generated/src/splash_screen/: SplashViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: background.cpp background_overlay.cpp BitmapDatabase.cpp icon_ai.cpp icon_ble.cpp icon_info.cpp icon_measurements.cpp icon_music.cpp st_logo1.cpp st_logo2.cpp sw1_pic.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: DrawableList.cpp MenuContainer.cpp ScrollBase.cpp ScrollList.cpp
  group Application/User/TouchGFX/gui/menu_screen
    ../TouchGFX/gui/src/menu_screen/: MenuPresenter.cpp MenuView.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/gui/popup_screen
    ../TouchGFX/gui/src/popup_screen/: PopUpPresenter.cpp PopUpView.cpp
  group Application/User/TouchGFX/gui/splash_screen
    ../TouchGFX/gui/src/splash_screen/: SplashPresenter.cpp SplashView.cpp
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp STM32L5HAL_DPI.cpp STM32L5Instrumentation.cpp STM32L5TouchController.cpp
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c st7789h2_reg.c
  group Drivers/BSP/STM32L562E-DK
    ../../../../../Drivers/BSP/STM32L562E-DK/: stm32l562e_discovery.c stm32l562e_discovery_bus.c stm32l562e_discovery_lcd.c stm32l562e_discovery_ospi.c stm32l562e_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_ospi.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_sram.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_ll_fmc.c stm32l5xx_ll_lpuart.c stm32l5xx_ll_pwr.c stm32l5xx_ll_sdmmc.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group Middlewares/TouchGFX
    ../../Middlewares_Addons/touchgfx/os/: OSWrappers_cmsis.cpp
    ../../Middlewares_Addons/touchgfx/lib/core/cortex_m33/IAR8.x/: touchgfx_core_release.a
