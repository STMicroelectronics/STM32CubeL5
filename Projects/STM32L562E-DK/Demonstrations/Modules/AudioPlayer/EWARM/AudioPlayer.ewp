# IAR project AudioPlayer.ewp, settings and files
configuration STM32L562E-DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562QE ST STM32L562QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: ST; USE_HAL_DRIVER; STM32L562xx; USE_BPP=16; USE_STM32L562E_DISCO; FUNCTIONAL_PART_AVAILABLE; USE_SDCARD
  ICCARM.IExtraOptions: --diag_warning Pa082; --diag_suppress Pa082; --diag_warning Pe2464; --diag_suppress Pe2464
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\..\..\Config; ..\Addons\Common\Inc; ..\Addons\SRC236\Inc; ..\Addons\SRC441\Inc; ..\TouchGFX\gui\include; ..\TouchGFX\target\; ..\TouchGFX\generated\fonts\include; ..\TouchGFX\generated\images\include; ..\TouchGFX\generated\texts\include; ..\TouchGFX\generated\gui_generated\include; ..\..\..\Middlewares_Addons\TouchGFX\framework\include; ..\..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\BSP\STM32L562E-DK; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM33_NTZ\non_secure
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ST; STM32L562xx; USE_BPP=16; CORE_CM33; USE_STM32L562E_DISCO; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: AudioPlayer-STM32L562E-DK_OoB.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: audio_bin_file
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08050000
  ILINK.IlinkIcfFile: stm32l562xe_flash.icf
  ILINK.IlinkExtraOptions: --diag_warning Lc059; --diag_suppress Lc059
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Source/Templates/iar/: startup_stm32l562xx.s
  group Application/User/Core
    ../Core/Src/: audio_player_app.c coders.c freertos.c fwkmempool.c main.cpp player.c sd_diskio.c stm32l5xx_hal_msp.c stm32l5xx_hal_timebase_tim.c stm32l5xx_it.c storage.c wavprocess.c
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_SairaCondensed_Bold_12_4bpp_0.cpp Font_SairaCondensed_Medium_12_4bpp_0.cpp Font_SairaCondensed_Medium_14_4bpp_0.cpp Font_SairaCondensed_Medium_14_4bpp_4.cpp Font_SairaCondensed_Medium_16_4bpp_0.cpp Font_SairaCondensed_Medium_24_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_SairaCondensed_Bold_12_4bpp.cpp Kerning_SairaCondensed_Medium_12_4bpp.cpp Kerning_SairaCondensed_Medium_14_4bpp.cpp Kerning_SairaCondensed_Medium_16_4bpp.cpp Kerning_SairaCondensed_Medium_24_4bpp.cpp Table_SairaCondensed_Bold_12_4bpp.cpp Table_SairaCondensed_Medium_12_4bpp.cpp Table_SairaCondensed_Medium_14_4bpp.cpp Table_SairaCondensed_Medium_16_4bpp.cpp Table_SairaCondensed_Medium_24_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/audio_player_screen
    ../TouchGFX/generated/gui_generated/src/audio_player_screen/: audio_playerViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../TouchGFX/generated/gui_generated/src/containers/: trackBase.cpp trackSelectorBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: audio_background.cpp BitmapDatabase.cpp led_on.cpp
  group Application/User/TouchGFX/generated/images/animation
    ../TouchGFX/generated/images/src/animation/: animation0000.cpp animation0001.cpp animation0002.cpp animation0003.cpp animation0004.cpp animation0005.cpp animation0006.cpp animation0007.cpp animation0008.cpp animation0009.cpp animation0010.cpp animation0011.cpp animation0012.cpp animation0013.cpp animation0014.cpp
  group Application/User/TouchGFX/generated/images/buttons
    ../TouchGFX/generated/images/src/buttons/: bottom_bar.cpp button_album.cpp button_album_pressed.cpp button_back.cpp button_back_pressed.cpp button_close_album.cpp button_close_album_pressed.cpp button_next_track_overlay.cpp button_next_track_pressed.cpp button_prev_track_overlay.cpp button_prev_track_pressed.cpp icon_low_power.cpp icon_low_power_pressed.cpp icon_pause.cpp icon_play.cpp
  group Application/User/TouchGFX/generated/images/powerSave
    ../TouchGFX/generated/images/src/powerSave/: button_cancel.cpp button_cancel_pressed.cpp power_save_icon.cpp power_save_title_and_icon.cpp
  group Application/User/TouchGFX/generated/images/slider
    ../TouchGFX/generated/images/src/slider/: audio_slider_bar.cpp audio_slider_fill_paused.cpp audio_slider_fill_playing.cpp audio_slider_knob.cpp volume_bar.cpp volume_bar_empty_bg.cpp volume_bar_fill.cpp volume_handle.cpp
  group Application/User/TouchGFX/generated/images/tracks
    ../TouchGFX/generated/images/src/tracks/: content_indicator.cpp content_indicator_bar.cpp icon_list_pause.cpp icon_list_play.cpp icon_repeat_off.cpp icon_repeat_on.cpp icon_shuffle_off.cpp icon_shuffle_on.cpp shadow_list_bottom.cpp shadow_list_top.cpp shadow_list_topBOTTOM.cpp track_list_box.cpp track_list_box_selected.cpp track_list_container.cpp
  group Application/User/TouchGFX/generated/images/volume
    ../TouchGFX/generated/images/src/volume/: icon_volume_high.cpp icon_volume_high_pressed.cpp icon_volume_low.cpp icon_volume_low_pressed.cpp icon_volume_medium.cpp icon_volume_medium_pressed.cpp icon_volume_muted.cpp icon_volume_muted_pressed.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/audio_player_screen
    ../TouchGFX/gui/src/audio_player_screen/: audio_playerPresenter.cpp audio_playerView.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: track.cpp trackSelector.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp STM32L5HAL_DPI.cpp STM32L5Instrumentation.cpp STM32L5TouchController.cpp
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../../../../../Drivers/BSP/Components/hx8347i/: hx8347i.c hx8347i_reg.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c st7789h2_reg.c
  group Drivers/BSP/STM32L562E-DK
    ../../../../../../Drivers/BSP/STM32L562E-DK/: stm32l562e_discovery.c stm32l562e_discovery_audio.c stm32l562e_discovery_bus.c stm32l562e_discovery_lcd.c stm32l562e_discovery_ospi.c stm32l562e_discovery_sd.c stm32l562e_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_dac.c stm32l5xx_hal_dac_ex.c stm32l5xx_hal_dfsdm.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_ospi.c stm32l5xx_hal_pcd.c stm32l5xx_hal_pcd_ex.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_sai.c stm32l5xx_hal_sai_ex.c stm32l5xx_hal_sd.c stm32l5xx_hal_sram.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_ll_fmc.c stm32l5xx_ll_lpuart.c stm32l5xx_ll_pwr.c stm32l5xx_ll_sdmmc.c stm32l5xx_ll_usb.c
  group Middlewares/AudioCodecs/SRC
    ../Addons/SRC236/Lib/: SRC236_CM33_wc32.a
    ../Addons/SRC441/Lib/: SRC441_CM33_wc32.a
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group Middlewares/TouchGFX
    ../../../Middlewares_Addons/touchgfx/os/: OSWrappers_cmsis.cpp
    ../../../Middlewares_Addons/touchgfx/lib/core/cortex_m33/IAR8.x/: touchgfx_core_release.a
