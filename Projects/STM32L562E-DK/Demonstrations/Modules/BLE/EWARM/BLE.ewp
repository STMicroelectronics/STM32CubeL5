# IAR project BLE.ewp, settings and files
configuration STM32L562E-DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562QE ST STM32L562QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32L562xx; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\Config; ..\..\..\Config; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso; ..\..\..\..\..\..\Drivers\BSP\STM32L562E-DK; ..\..\..\Middlewares_Addons\STM32_MotionAR_Library\Inc; ..\..\..\Middlewares_Addons\STM32_MotionCP_Library\Inc; ..\..\..\Middlewares_Addons\STM32_MotionGR_Library\Inc; ..\..\..\Middlewares_Addons\STM32_MetaDataManager; ..\..\..\Middlewares_Addons\BlueNRG-MS\utils; ..\..\..\Middlewares_Addons\BlueNRG-MS\includes; ..\..\..\Middlewares_Addons\BlueNRG-MS\hci\hci_tl_patterns\Basic; ..\..\..\..\..\..\Utilities\lcd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE-STM32L562E-DK_OoB.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08038000
  ILINK.IlinkIcfFile: stm32l562xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l562xx.s
  group Application/User
    ../Core/Src/: hci_tl_interface.c HWAdvanceFeatures.c main.c MotionAR_Manager.c MotionCP_Manager.c MotionGR_Manager.c sensor_service.c stm32l562e_discovery_motion_sensors_ex.c stm32l5xx_hal_msp.c stm32l5xx_it.c TargetPlatform.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c st7789h2_reg.c
  group Drivers/BSP/STM32L562E-DK
    ../../../../../../Drivers/BSP/STM32L562E-DK/: stm32l562e_discovery.c stm32l562e_discovery_bus.c stm32l562e_discovery_lcd.c stm32l562e_discovery_motion_sensors.c stm32l562e_discovery_ospi.c stm32l562e_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_ospi.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_sram.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_ll_fmc.c
  group Middlewares/BlueNRG-MS/HCI
    ../../../Middlewares_Addons/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/HCI/Controller
    ../../../Middlewares_Addons/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/hci_tl_patterns/Basic
    ../../../Middlewares_Addons/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-MS/Utils
    ../../../Middlewares_Addons/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/MetaDataManager
    ../../../Middlewares_Addons/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/STM32_MotionAR
    ../../../Middlewares_Addons/STM32_MotionAR_Library/Lib/: MotionAR_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionCP
    ../../../Middlewares_Addons/STM32_MotionCP_Library/Lib/: MotionCP_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionGR
    ../../../Middlewares_Addons/STM32_MotionGR_Library/Lib/: MotionGR_CM4F_wc32_ot.a
  group Utilities/lcd
    ../../../../../../Utilities/lcd/: stm32_lcd.c
