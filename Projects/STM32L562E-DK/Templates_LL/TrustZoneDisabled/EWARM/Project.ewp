# IAR project Project.ewp, settings and files
configuration STM32L562E-DK_Templates_LL (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562QE ST STM32L562QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32L562xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32l562xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_ll_adc.c stm32l5xx_ll_comp.c stm32l5xx_ll_crc.c stm32l5xx_ll_crs.c stm32l5xx_ll_dac.c stm32l5xx_ll_dma.c stm32l5xx_ll_exti.c stm32l5xx_ll_gpio.c stm32l5xx_ll_i2c.c stm32l5xx_ll_lptim.c stm32l5xx_ll_lpuart.c stm32l5xx_ll_opamp.c stm32l5xx_ll_pka.c stm32l5xx_ll_pwr.c stm32l5xx_ll_rcc.c stm32l5xx_ll_rng.c stm32l5xx_ll_rtc.c stm32l5xx_ll_spi.c stm32l5xx_ll_tim.c stm32l5xx_ll_ucpd.c stm32l5xx_ll_usart.c stm32l5xx_ll_utils.c
  group Example/EWARM
    ./: startup_stm32l562xx.s
  group Example/User
    ../Src/: main.c stm32l5xx_it.c
