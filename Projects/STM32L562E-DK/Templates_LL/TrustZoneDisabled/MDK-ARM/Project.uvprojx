# Keil uVision project Project.uvprojx, settings and files
target STM32L562E-DK_Templates_LL (6120000::V6.12::.\ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: $PROJ_FNAME$
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L562xx,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../Drivers/STM32L5xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: stm32l562xe_flash.sct
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_ll_adc.c stm32l5xx_ll_comp.c stm32l5xx_ll_crc.c stm32l5xx_ll_crs.c stm32l5xx_ll_dac.c stm32l5xx_ll_dma.c stm32l5xx_ll_exti.c stm32l5xx_ll_gpio.c stm32l5xx_ll_i2c.c stm32l5xx_ll_lptim.c stm32l5xx_ll_lpuart.c stm32l5xx_ll_opamp.c stm32l5xx_ll_pka.c stm32l5xx_ll_pwr.c stm32l5xx_ll_rcc.c stm32l5xx_ll_rng.c stm32l5xx_ll_rtc.c stm32l5xx_ll_spi.c stm32l5xx_ll_tim.c stm32l5xx_ll_ucpd.c stm32l5xx_ll_usart.c stm32l5xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32l562xx.s
  group Example/User
    ../Src/: main.c stm32l5xx_it.c
software components: CMSIS:CORE 4.3.0
