# IAR project Project_ns.ewp, settings and files
configuration STM32L562E-DK_Templates_TrustZone (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562QE ST STM32L562QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: STM32L562xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\NonSecure\Inc; ..\Secure_nsclib; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L562E-Discovery; ..\..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_ns.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32l562xe_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ..\Secure_nsclib\secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c st7789h2_reg.c
  group Drivers/BSP/STM32L562E-Discovery
    ../../../../../Drivers/BSP/STM32L562E-Discovery/: stm32l562e_discovery.c stm32l562e_discovery_audio.c stm32l562e_discovery_bus.c stm32l562e_discovery_idd.c stm32l562e_discovery_lcd.c stm32l562e_discovery_motion_sensors.c stm32l562e_discovery_ospi.c stm32l562e_discovery_sd.c stm32l562e_discovery_ts.c
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32l5xx_ns.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal_comp.c stm32l5xx_hal_cortex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_cryp.c stm32l5xx_hal_cryp_ex.c stm32l5xx_hal_dac.c stm32l5xx_hal_dac_ex.c stm32l5xx_hal_dfsdm.c stm32l5xx_hal_dfsdm_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_fdcan.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_hash.c stm32l5xx_hal_hash_ex.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_irda.c stm32l5xx_hal_iwdg.c stm32l5xx_hal_lptim.c stm32l5xx_hal_mmc.c stm32l5xx_hal_mmc_ex.c stm32l5xx_hal_nand.c stm32l5xx_hal_nor.c stm32l5xx_hal_opamp.c stm32l5xx_hal_opamp_ex.c stm32l5xx_hal_ospi.c stm32l5xx_hal_pcd.c stm32l5xx_hal_pcd_ex.c stm32l5xx_hal_pka.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rng.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_sai.c stm32l5xx_hal_sai_ex.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c stm32l5xx_hal_smartcard.c stm32l5xx_hal_smartcard_ex.c stm32l5xx_hal_smbus.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_sram.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_tsc.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_usart.c stm32l5xx_hal_usart_ex.c stm32l5xx_hal_wwdg.c stm32l5xx_ll_fmc.c stm32l5xx_ll_sdmmc.c stm32l5xx_ll_usb.c
  group Example/EWARM
    ./: startup_stm32l562xx.s
  group Example/User
    ../NonSecure/Src/: main.c stm32l5xx_hal_msp.c stm32l5xx_it.c
