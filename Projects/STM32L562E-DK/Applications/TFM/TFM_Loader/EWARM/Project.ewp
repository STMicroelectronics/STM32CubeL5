# IAR project Project.ewp, settings and files
configuration STM32L562E-DK_TFM_Loader (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562QE ST STM32L562QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32L562xx; USE_HAL_DRIVER; LOCAL_LOADER_CONFIG; BL2
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\test\suites\crypto; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\driver; ..\..\Linker; Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L562E-DK; ..\..\..\..\..\..\Drivers\BSP\Components\mx25lm51245g
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild.cmd "$PROJ_DIR$"
  postbuild: cmd /C "cmd /C postbuild.bat "$PROJ_DIR$" "nonsecure""
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: flash.icf.i
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_ospi.c stm32l5xx_hal_otfdec.c
  group Drivers/BSP/STM32L562E-DK
    ../../../../../../Drivers/BSP/STM32L562E-DK/: stm32l562e_discovery_ospi.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Application/User
    ../Src/: com.c main.c fw_update_app.c ymodem.c common.c tick.c low_level_device.c low_level_flash.c low_level_ospi_flash.c low_level_ospi_device.c system_stm32l5xx.c
  group Application/EWARM
    ./: startup_stm32l562xx.s
  group Doc
    ../: readme.txt
