# Keil uVision project Project.uvprojx, settings and files
target STM32L562E-DK_TFM_Loader (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  AfterMake: postbuild.bat .
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L562xx,USE_HAL_DRIVER,LOCAL_LOADER_CONFIG,BL2
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Middlewares/Third_Party/trustedfirmware/test/suites/crypto;../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/driver;../../Linker;Inc;../../../../../../Drivers/BSP/STM32L562E-DK;../../../../../../Drivers/BSP/Components/mx25lm51245g
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: stm32l562xe_flash_ns.sct
  link misc: --predefine=-I../../Linker
--predefine=-DBL2
--entry=Reset_Handler
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_ospi.c stm32l5xx_hal_otfdec.c
  group Drivers/BSP/STM32L562E-DK
    ../../../../../../Drivers/BSP/STM32L562E-DK/: stm32l562e_discovery_ospi.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Application/User
    ../Src/: com.c main.c fw_update_app.c ymodem.c common.c tick.c low_level_device.c low_level_flash.c low_level_ospi_flash.c low_level_ospi_device.c system_stm32l5xx.c
  group Application/MDK-ARM
    ./: startup_stm32l562xx.s
  group Doc
    ../: readme.txt
