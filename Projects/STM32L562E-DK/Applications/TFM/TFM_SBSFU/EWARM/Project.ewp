# IAR project Project.ewp, settings and files
configuration STM32L562E-DK_TFM_SBSFU (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: STM32L562xx; __ARM_FEATURE_CMSE=3; USE_HAL_DRIVER; MCUBOOT_SIGN_RSA; MCUBOOT_SIGN_RSA_LEN=3072; MCUBOOT_VALIDATE_PRIMARY_SLOT; MCUBOOT_USE_FLASH_AREA_GET_SECTORS; MCUBOOT_TARGET_CONFIG=<flash_layout.h>; MBEDTLS_CONFIG_FILE=<config-boot.h>; __thumb2__; MCUBOOT_OVERWRITE_ONLY; MCUBOOT_IMAGE_NUMBER=2; BL2; TFM_DEV_MODE; Image$$=; Load$$LR$$=; $$ZI$$Base=$$Base; $$ZI$$Limit=$$Limit; $$RO$$Base=$$Base; $$RO$$Limit=$$Limit; _DATA$$RW$$Base=_DATA$$Base; _DATA$$RW$$Limit=_DATA$$Limit; _DATA$$ZI$$Base=_DATA$$Base; _DATA$$ZI$$Limit=_DATA$$Limit; _STACK$$ZI$$Base=_STACK$$Base; _STACK$$ZI$$Limit=_STACK$$Limit
  ICCARM.IExtraOptions: --cmse; -e; --vla; --silent; -DNO_TYPEOF
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L562E-Discovery; ..\..\Linker; Inc; ..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include\mbedtls; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\common; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\driver; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\bl2\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\bl2\ext\mcuboot; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\bl2\ext\mcuboot\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\bl2\ext\mcuboot\bootutil\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild.cmd "$PROJ_DIR$"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l562xx_bl2.icf.i
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker; --silent; --semihosting; --redirect; __write=__write_buffered
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l562xx_bl2.s
  group Application/User
    ../Src/: bl2_nv_services.c jumper.c low_level_com.c low_level_flash.c low_level_rng.c main.c mpu_armv8m_drv.c sha256_alt.c stm32l5xx_hal_msp.c system_stm32l5xx.c tfm_bl2_shared_data.c tfm_low_level_security.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_hash.c stm32l5xx_hal_hash_ex.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rng.c stm32l5xx_hal_rng_ex.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
  group Middlewares/mbedtls
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group Middlewares/trustedfirmware
    ../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/: bl2_main.c flash_map.c keys.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/src/: boot_record.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/bootutil/src/: bootutil_misc.c image_rsa.c image_validate.c loader.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common/: uart_stdout.c
