# Keil uVision project Project.uvprojx, settings and files
target STM32L562E-DK_TFM_SBSFU_Boot (6100001::V6.10.1::.\ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NDEBUG,TFM_DEV_MODE, USE_FULL_LL_DRIVER,STM32L562xx,USE_HAL_DRIVER,MCUBOOT_SIGN_RSA,MCUBOOT_SIGN_RSA_LEN=3072,MCUBOOT_VALIDATE_PRIMARY_SLOT,BL2,MCUBOOT_OVERWRITE_ONLY, MCUBOOT_USE_FLASH_AREA_GET_SECTORS,MCUBOOT_IMAGE_NUMBER=2,MCUBOOT_TARGET_CONFIG=<flash_layout.h>,MBEDTLS_CONFIG_FILE=<config-boot.h>,__thumb2__
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L562E-DK;../../Linker;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/mbedTLS/include/mbedtls;../../../../../../Middlewares/Third_Party/trustedfirmware;../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common;../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/driver;../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/include;../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot;../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/include;../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/bootutil/include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: .\stm32l5xx_bl2.sct
  link misc: --predefine=-I../../Linker
--predefine=-DBL2
--predefine=-DMCUBOOT_IMAGE_NUMBER=2
--predefine=-DTFM_PSA_API
--predefine=-DMCUBOOT_IMAGE_NUMBER=2
--entry=Reset_Handler
  group Doc
    ../../: readme.txt
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_hash.c stm32l5xx_hal_hash_ex.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_exti.c stm32l5xx_ll_usart.c stm32l5xx_ll_rcc.c stm32l5xx_hal_rng_ex.c stm32l5xx_hal_rng.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c
  group Middlewares/trustedfirmware
    ../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/: bl2_main.c flash_map.c keys.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/bootutil/src/: bootutil_misc.c image_rsa.c image_validate.c loader.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/src/: boot_record.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common/: uart_stdout.c
  group Middlewares/mbedtls
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c pk_wrap.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509write_crt.c x509write_csr.c x509_create.c x509_crl.c x509_crt.c x509_csr.c xtea.c
  group Application/User
    ../src/: low_level_com.c low_level_flash.c system_stm32l5xx.c
    ../Src/: main.c bl2_nv_services.c tfm_low_level_security.c jumper.c low_level_rng.c tfm_bl2_shared_data.c stm32l5xx_hal_msp.c mpu_armv8m_drv.c sha256_alt.c
  group Application/MDK-ARM
    ./: startup_stm32l5xx_bl2.s
software components: CMSIS:CORE 5.1.2
