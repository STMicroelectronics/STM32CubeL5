# Keil uVision project Project_ns.uvprojx, settings and files
target STM32L562E-DK_TFM_NonSecure (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  AfterMake: postbuild.bat .  "1.0.0" "nonsecure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L562xx,USE_HAL_DRIVER,SST_ENCRYPTION,TFM_PSA_API,TFM_LVL=2,TFM_LEGACY_API,BL2
  c include: ../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L562E-DK;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/spm;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core;../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services;../../../../../../Middlewares/Third_Party/trustedfirmware/interface/include;../../../../../../Middlewares/Third_Party/trustedfirmware/platform/include;../../../../../../Middlewares/Third_Party/trustedfirmware;../NonSecure/Inc;../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common;../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/driver;../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/include;../../../../../../Middlewares/Third_Party/trustedfirmware/test/suites/crypto;../../Linker;../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/inc;../../../../../../Middlewares/Third_Party/trustedfirmware//secure_fw/core/include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: .\stm32l5xx_ns.sct
  link misc: --predefine=-I../../Linker
--predefine=-DBL2
./veneer.o
--predefine=-DMCUBOOT_IMAGE_NUMBER=2
--predefine=-DTFM_PSA_API
  group Application/MDK-ARM
    ./: startup_stm32l562xx_ns.s
  group Application/User
    ../NonSecure/Src/: com.c common.c flash_if.c fw_update_app.c main.c mpu_armv8m_drv.c stm32l5xx_it.c system_stm32l5xx.c test_protections.c tfm_app.c tfm_ns_lock.c ymodem.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
  group Middlewares/trustedfirmware/core
    ../../../../../../Middlewares/Third_Party/trustedfirmware/interface/src/: tfm_crypto_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_psa_ns_api.c tfm_sst_ipc_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/src/: UsefulBuf.c
  group Middlewares/trustedfirmware/test
    ../../../../../../Middlewares/Third_Party/trustedfirmware/test/suites/crypto/: crypto_tests_common.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/test/framework/: test_framework.c test_framework_helpers.c
software components: CMSIS:CORE 5.1.2
