# IAR project Project_ns.ewp, settings and files
configuration STM32L562E-DK_TFM_NonSecure (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: STM32L562xx; MCUBOOT_IMAGE_NUMBER=2; USE_HAL_DRIVER; SST_ENCRYPTION; TFM_PSA_API; TFM_LVL=2; TFM_LEGACY_API
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L562E-DK; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\spm; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\core; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\services; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\interface\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware; ..\NonSecure\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\common; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\driver; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\bl2\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\test\suites\crypto; ..\..\Linker; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\inc; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\/secure_fw\core\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_ns.cmd "$PROJ_DIR$"
  postbuild: cmd /C "cmd /C postbuild.bat "$PROJ_DIR$"  "1.0.0" "nonsecure""
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l562xx_flash_ns.icf.i
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker
  ILINK.IlinkAdditionalLibs: STM32L562E-DK_S\Exe\Project_import_lib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l562xx_ns.s
  group Application/User
    ../NonSecure/Src/: com.c common.c flash_if.c fw_update_app.c main.c mpu_armv8m_drv.c stm32l5xx_it.c system_stm32l5xx.c test_protections.c tfm_app.c tfm_ns_lock.c ymodem.c
    ../NonSecure/Inc/: com.h
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
  group Middlewares/trustedfirmware/core
    ../../../../../../Middlewares/Third_Party/trustedfirmware/interface/src/: tfm_crypto_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_psa_ns_api.c tfm_sst_ipc_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/src/: UsefulBuf.c
  group Middlewares/trustedfirmware/test
    ../../../../../../Middlewares/Third_Party/trustedfirmware/test/suites/crypto/: crypto_tests_common.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/test/framework/: test_framework.c test_framework_helpers.c
