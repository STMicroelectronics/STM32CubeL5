# IAR project Project_s.ewp, settings and files
configuration STM32L562E-DK_TFM_Secure (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: STM32L562xx; BL2; USE_HAL_DRIVER; MCUBOOT_SIGN_RSA; MCUBOOT_VALIDATE_SLOT0; MCUBOOT_USE_FLASH_AREA_GET_SECTORS; SST_ENCRYPTION; TFM_PSA_API=1; TFM_LVL=2; TFM_LEGACY_API; SST_CREATE_FLASH_LAYOUT; MULADDC_CANNOT_USE_R7; MBEDTLS_CONFIG_FILE=<tfm_mbedcrypto_config.h>; NO_TYPEOF; ITS_CREATE_FLASH_LAYOUT; Image$$=; Load$$LR$$=; $$ZI$$Base=$$Base; $$ZI$$Limit=$$Limit; $$RO$$Base=$$Base; $$RO$$Limit=$$Limit; $$RW$$Base=$$Base; $$RW$$Limit=$$Limit; _DATA$$RW$$Base=_DATA$$Base; _DATA$$RW$$Limit=_DATA$$Limit; _DATA$$ZI$$Base=_DATA$$Base; _DATA$$ZI$$Limit=_DATA$$Limit; _STACK$$ZI$$Base=_STACK$$Base; _STACK$$ZI$$Limit=_STACK$$Limit
  ICCARM.IExtraOptions: --cmse; -e; --vla; --silent; -DNO_TYPEOF; -DCOMPILER=IARARM; -DCMAKE_BUILD_TYPE=RelWithDebInfo
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L562E-Discovery; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\test\suites\attestation; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\inc; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\core\arch\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedtls\library; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\interface\include\psa_manifest; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\core\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\services\initial_attestation\psa_manifest; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\spm; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\core; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\core\ipc; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\core\ipc\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\services; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\services\platform; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\services\crypto; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\services\audit_logging; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\services\secure_storage; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\services\initial_attestation; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\interface\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\include; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\inc; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\util; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\t_cose\inc; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\lib\t_cose\src; ..\..\Linker; ..\Secure\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\common; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\driver; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\bl2\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\mbedtls; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\psa; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\psa; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\cmake_build_gcc\secure_fw\services\crypto\mbedcrypto\mbedcrypto_install\include\mbedcrypto\psa; ..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\secure_fw\services\initial_attestation\psa_manifest
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_s.cmd "$PROJ_DIR$"
  postbuild: cmd /C "cmd /C postbuild.bat "$PROJ_DIR$"  "1.0.0" "secure""
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: tfm_common_s.icf.i
  ILINK.IlinkExtraOptions: --semihosting; --redirect; __write=__write_buffered
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l562xx_s.s
  group Application/User
    ../Secure/Src/: aes_alt.c attest_hal.c dummy_boot_seed.c dummy_crypto_keys.c dummy_device_id.c dummy_nv_counters.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c gcm_alt.c low_level_com.c low_level_flash.c low_level_rng.c md5_alt.c mpu_armv8m_drv.c sha1_alt.c sha256_alt.c spm_hal.c system_stm32l5xx.c target_cfg.c tfm_platform_system.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_cryp.c stm32l5xx_hal_cryp_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_hash.c stm32l5xx_hal_hash_ex.c stm32l5xx_hal_pka.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rng.c stm32l5xx_hal_rng_ex.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_slot_management.c psa_crypto_storage.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: certs.c debug.c
  group Middlewares/trustedfirmware/core
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/initial_attestation/: attest_token.c attestation_core.c attestation_key.c tfm_attestation.c tfm_attestation_req_mngr.c tfm_attestation_secure_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/crypto/: crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_cipher.c crypto_generator.c crypto_hash.c crypto_init.c crypto_key.c crypto_mac.c tfm_crypto_secure_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/src/: ieee754.c qcbor_decode.c qcbor_encode.c UsefulBuf.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/internal_trusted_storage/flash/: its_flash.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs_dblock.c its_flash_fs_mblock.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/internal_trusted_storage/: its_utils.c tfm_internal_trusted_storage.c tfm_its_req_mngr.c tfm_its_secure_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core/ipc/: psa_client.c psa_service.c tfm_message_queue.c tfm_pools.c tfm_svcalls.c tfm_thread.c tfm_wait.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/util/: qcbor_util.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/spm/: spm_api.c spm_api_ipc.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/secure_storage/crypto/: sst_crypto_interface.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/secure_storage/: sst_encrypted_object.c sst_object_system.c sst_object_table.c sst_utils.c tfm_protected_storage.c tfm_sst_req_mngr.c tfm_sst_secure_api.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/secure_storage/flash/: sst_flash.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/secure_storage/flash_fs/: sst_flash_fs.c sst_flash_fs_dblock.c sst_flash_fs_mblock.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/services/secure_storage/nv_counters/: sst_nv_counters.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/lib/t_cose/src/: t_cose_psa_crypto_hash.c t_cose_psa_crypto_sign.c t_cose_psa_crypto_verify.c t_cose_sign1_sign.c t_cose_sign1_verify.c t_cose_util.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core/arch/: tfm_arch_v8m_main.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/core/: tfm_boot_data.c tfm_core.c tfm_core_log.c tfm_core_mem_check.c tfm_core_svcalls_ipc.c tfm_core_utils.c tfm_nspm_ipc.c tfm_secure_api.c tfm_spm_services.c tfm_utils.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/secure_fw/ns_callable/: tfm_psa_api_veneers.c tfm_veneers.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common/: uart_stdout.c
