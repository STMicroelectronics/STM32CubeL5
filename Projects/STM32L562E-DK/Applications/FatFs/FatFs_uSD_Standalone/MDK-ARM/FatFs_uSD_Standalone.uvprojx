# Keil uVision project FatFs_uSD_Standalone.uvprojx, settings and files
target FatFs_uSD_Standalone (ARM-ADS)
  device: STM32L562QEIxP STMicroelectronics
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2003FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: FatFs_uSD_Standalone +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L562xx
  c include: ../FATFS/Target;../FATFS/App;../Core/Inc;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32L562E-Discovery;../../../../../../Drivers/BSP/Components/mfxstm32l152
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: stm32l562xe_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32l562xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l5xx_hal_msp.c stm32l5xx_it.c
  group Application/User/FATFS/App
    ../FATFS/App/: app_fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: sd_diskio.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/STM32L562E-Discovery
    ../../../../../../Drivers/BSP/STM32L562E-Discovery/: stm32l562e_discovery.c stm32l562e_discovery_bus.c stm32l562e_discovery_sd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_mmc.c stm32l5xx_hal_mmc_ex.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
software components: CMSIS:CORE 4.3.0
