# IAR project Project_ns.ewp, settings and files
configuration FatFs_uSD_TrustZone (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562QE ST STM32L562QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32L562xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\NonSecure\FATFS\App; ..\NonSecure\FATFS\Target; ..\NonSecure\Core\Inc; ..\NonSecure\Core\Src; ..; ..\Secure_nsclib; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L5xx\Include; ..\..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32L5xx_HAL_Driver\Src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\option; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Drivers\BSP\STM32L562E-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\mfxstm32l152
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_ns.srec
  ILINK.IlinkOutputFile: project_ns.out
  ILINK.IlinkIcfFile: stm32l562xe_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ..\Secure_nsclib\secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/STM32L562E-Discovery
    ../../../../../../Drivers/BSP/STM32L562E-Discovery/: stm32l562e_discovery.c stm32l562e_discovery_bus.c
  group Drivers/CMSIS
    ../NonSecure/Core/Src/: system_stm32l5xx_ns.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
  group Example/EWARM
    ./: startup_stm32l562xx.s
  group Example/User/Core
    ../NonSecure/Core/Src/: main.c stm32l5xx_hal_msp.c stm32l5xx_it.c
  group Example/User/FATFS/App
    ../NonSecure/FATFS/App/: app_fatfs.c
  group Example/User/FATFS/Target
    ../NonSecure/FATFS/Target/: sd_diskio.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
