# Keil uVision project FreeRTOS_ThreadCreation.uvprojx, settings and files
target FreeRTOS_ThreadCreation (6140000::V6.14::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: FreeRTOS_ThreadCreation +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L562xx
  c include: ../Inc;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../../Drivers/BSP/STM32L562E-DK
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: stm32l562xe_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32l562xx.s
  group Application/User
    ../Src/: main.c stm32l5xx_it.c stm32l5xx_hal_msp.c stm32l5xx_hal_timebase_tim.c app_freertos.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L562E-DK
    ../../../../../../Drivers/BSP/STM32L562E-DK/: stm32l562e_discovery.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal_gtzc.c stm32l5xx_hal_exti.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_icache.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
software components: CMSIS:CORE 5.4.0
