# Keil uVision project HR.uvprojx, settings and files
target STM32L562E-DK_HR (ARM-ADS)
  device: STM32L562QEIxQ STMicroelectronics
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2003FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: BLE
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L562xx,USE_HAL_DRIVER,SET_L2CAP_CONN_UPD_REQ_COMMAND,ENABLE_SPI_FIX,BLUENRG_MS
  c include: ../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../Common/ble_core/;../../Common/ble_services/;../../Common/debug/;../../Common/hw/;../../Common/tl/;../../Common/utilities/;../../Common/;../Inc/
  library: MicroLIB
  scatter file: stm32l562xe_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32l562xx.s
  group Application/Common/ble_core
    ../../Common/ble_core/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c osal.c
  group Application/Common/ble_services
    ../../Common/ble_services/: dis.c hrs.c svc_ctl.c
  group Application/Common/hw_interface
    ../../Common/hw/: hw_lpm.c hw_spi.c hw_timerserver.c
  group Application/Common/tl
    ../../Common/tl/: tl_ble_hci.c tl_ble_io.c tl_ble_reassembly.c tl_ble_spi.c
  group Application/Common/utilities
    ../../Common/utilities/: list.c lpm.c memory_manager.c scheduler.c
  group Application/HR_Example
    ../Src/: dis_app.c hr.c hrs_app.c main.c stm32l5xx_it.c system_stm32l5xx.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_gpio.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_spi.c
software components: CMSIS:CORE 4.3.0
