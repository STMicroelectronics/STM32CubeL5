# IAR project PKA_ModularExponentiation_IT.ewp, settings and files
configuration PKA_ModularExponentiation_IT (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562QE ST STM32L562QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L562xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32L562E-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PKA_ModularExponentiation_IT.hex
  ILINK.IlinkOutputFile: PKA_ModularExponentiation_IT.out
  ILINK.IlinkIcfFile: stm32l562xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l562xx.s
  group Application/User
    ../Src/: ciphertext.c main.c plaintext.c rsa_priv_2048.c rsa_pub_2048.c stm32l5xx_hal_msp.c stm32l5xx_it.c
  group BSP/STM32L562E-DK
    ../../../../../../Drivers/BSP/STM32L562E-Discovery/: stm32l562e_discovery.c
  group Doc
    ../: readme.txt
    ../Src/: rsa_priv_2048.pem rsa_pub_2048.pem
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_pka.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c
