<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FLASH_BlockBased_TrustZone_S.ewp</path>
  </project><project>
    <path>$WS_DIR$\FLASH_BlockBased_TrustZone_NS.ewp</path>
  </project>
  <batchBuild />
</workspace>
