<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DFSDM_AudioRecord.ewp</path>
  </project>
  <batchBuild />
</workspace>
