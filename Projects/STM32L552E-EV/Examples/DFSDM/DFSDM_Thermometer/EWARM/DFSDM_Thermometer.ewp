# IAR project DFSDM_Thermometer.ewp, settings and files
configuration DFSDM_Thermometer (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L552xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32L552E-EV; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Utilities/lcd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DFSDM_Thermometer.hex
  ILINK.IlinkOutputFile: DFSDM_Thermometer.out
  ILINK.IlinkIcfFile: stm32l552xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l552xx.s
  group Application/User
    ../Src/: main.c stm32l5xx_it.c stm32l5xx_hal_msp.c
  group BSP/Components
    ../../../../../../Drivers/BSP/Components/hx8347i/: hx8347i.c hx8347i_reg.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group BSP/STM32L552E-EV
    ../../../../../../Drivers/BSP/STM32L552E-EV/: stm32l552e_eval.c stm32l552e_eval_bus.c stm32l552e_eval_io.c stm32l552e_eval_lcd.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal_sram.c stm32l5xx_ll_fmc.c stm32l5xx_hal_dfsdm.c stm32l5xx_hal_dfsdm_ex.c stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_icache.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c
  group Drivers/Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
