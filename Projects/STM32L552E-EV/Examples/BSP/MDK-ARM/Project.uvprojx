# Keil uVision project Project.uvprojx, settings and files
target STM32L552E-EV-BSP (6120000::V6.12::.\ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: BSP
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L552xx,USE_HAL_DRIVER
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L552E-EV;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
    ../../../../../Drivers/BSP/Components/hx8347i/: hx8347i.c hx8347i_reg.c
    ../../../../../Drivers/BSP/Components/iss66wvh8m8/: iss66wvh8m8.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811_reg.c
  group Drivers/BSP/STM32L552E-EV
    ../../../../../Drivers/BSP/STM32L552E-EV/: stm32l552e_eval.c stm32l552e_eval_audio.c stm32l552e_eval_bus.c stm32l552e_eval_io.c stm32l552e_eval_lcd.c stm32l552e_eval_ospi.c stm32l552e_eval_sd.c stm32l552e_eval_sram.c stm32l552e_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dfsdm.c stm32l5xx_hal_dfsdm_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_ospi.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_sai.c stm32l5xx_hal_sai_ex.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c stm32l5xx_hal_sram.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_ll_fmc.c stm32l5xx_ll_sdmmc.c
  group Example/MDK-ARM
    ./: startup_stm32l552xx.s
  group Example/User
    ../Src/: audio_play.c audio_record.c joystick.c lcd.c led.c main.c ospi_nor.c ospi_ram.c sd.c sram.c stm32l5xx_it.c touchscreen.c
  group Utilities
    ../../../../../Utilities/lcd/: stm32_lcd.c
