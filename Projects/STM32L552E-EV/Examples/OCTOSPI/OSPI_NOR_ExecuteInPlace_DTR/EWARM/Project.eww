<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\OSPI_NOR_ExecuteInPlace_DTR.ewp</path>
  </project>
  <batchBuild />
</workspace>
