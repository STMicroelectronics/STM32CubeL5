# Keil uVision project Demo.uvprojx, settings and files
target STM32L552E-EV (6140000::V6.14::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: STM32CubeL5_Demo_STM32L552E-EV +hex
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L552xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,_SNK,_RTOS,USBPDCORE_LIB_PD3_FULL,USBPD_PORT_COUNT=1,__DEBUG_CAD,_TRACE,_PPS=USBPD_FALSE,_SRC_CAPA_EXT=USBPD_FALSE,_SNK_CAPA_EXT=USBPD_FALSE,_ALERT=USBPD_TRUE,_BATTERY=USBPD_FALSE,_STATUS=USBPD_TRUE,_MANU_INFO=USBPD_TRUE,_GUI_INTERFACE,_VDM
  c include: ../Inc;../../Config;../../Common/Inc;../../Core/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L552E-EV;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc;../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32L5xx/inc;../../Modules/audio;../../Modules/lowpower;../../Modules/filebrowser;../../Modules/calendar;../../Modules/imagebrowser;../../Modules/main_app;../../Modules/ucpd;../../../../../Utilities/lcd;../../../../../Utilities/TRACER_EMB;../../../../../Utilities/GUI_INTERFACE
  asm include: ../Config;../../Modules/ucpd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: stm32l552xe_flash.sct
  link misc: --diag_suppress=L6329
  group Application/Common
    ../../Common/Src/: sd_diskio.c utils.c
  group Application/Core
    ../../Core/Src/: k_demo.c k_menu.c k_module.c k_storage.c k_tools.c k_widgets.c k_window.c
  group Application/MDK-ARM
    ./: startup_stm32l552xx.s
  group Application/Modules/AppMain
    ../../Modules/main_app/: app_main.c
  group Application/Modules/Audio
    ../../Modules/audio/: app_audio.c wave_player.c wave_recorder.c
  group Application/Modules/Calendar
    ../../Modules/calendar/: app_calendar.c
  group Application/Modules/FilesBrowser
    ../../Modules/filebrowser/: app_filesbrowser.c
  group Application/Modules/ImagesBrowser
    ../../Modules/imagebrowser/: app_imagesbrowser.c
  group Application/Modules/LowPower
    ../../Modules/lowpower/: app_lowpower.c
  group Application/Modules/Ucpd
    ../../Modules/ucpd/: app_ucpd.c demo_application.c usbpd_dpm_core.c usbpd_dpm_user.c usbpd_pwr_if.c usbpd_vdm_user.c
  group Application/User
    ../Src/: main.c stm32l5xx_hal_msp.c stm32l5xx_hal_timebase_tim.c stm32l5xx_it.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
    ../../../../../Drivers/BSP/Components/hx8347i/: hx8347i.c hx8347i_reg.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/STM32L552E-EV
    ../../../../../Drivers/BSP/STM32L552E-EV/: stm32l552e_eval.c stm32l552e_eval_audio.c stm32l552e_eval_bus.c stm32l552e_eval_idd.c stm32l552e_eval_io.c stm32l552e_eval_lcd.c stm32l552e_eval_sd.c stm32l552e_eval_usbpd_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Drivers
    ../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal_comp.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dac.c stm32l5xx_hal_dac_ex.c stm32l5xx_hal_dfsdm.c stm32l5xx_hal_dfsdm_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_opamp.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_sai.c stm32l5xx_hal_sai_ex.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_sram.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_ll_dma.c stm32l5xx_ll_fmc.c stm32l5xx_ll_rcc.c stm32l5xx_ll_sdmmc.c stm32l5xx_ll_tim.c stm32l5xx_ll_ucpd.c stm32l5xx_ll_usart.c stm32l5xx_ll_utils.c stm32l5xx_hal_icache.c
  group Middlewares/ST/STM32_USBPD_Library/Core
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM33_Keil.lib
  group Middlewares/ST/STM32_USBPD_Library/Devices/STM32L5XX
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32L5XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group Middlewares/Third_Party/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/Third_Party/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c event_groups.c timers.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS_V2
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
  group Utilities/lcd
    ../../../../../Utilities/lcd/: stm32_lcd.c
  group Utilities/GUI_INTERFACE
    ../../../../../Utilities/GUI_INTERFACE/: bsp_gui.c data_struct_tlv.c gui_api.c
  group Utilities/Tracer_Emb
    ../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
