# IAR project FatFs_uSD_DMA.ewp, settings and files
configuration FatFs_uSD_DMA (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L552xx
  ICCARM.CCIncludePath2: ../FATFS/Target; ../FATFS/App; ../Core/Inc; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/Third_Party/FatFs/src; ../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32L552E-EV; ../../../../../../Drivers/BSP/Components/mfxstm32l152
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FatFs_uSD_DMA.hex
  ILINK.IlinkOutputFile: FatFs_uSD_DMA.out
  ILINK.IlinkIcfFile: stm32l552xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l552xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l5xx_it.c stm32l5xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: app_fatfs.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152_reg.c mfxstm32l152.c
  group Drivers/BSP/STM32L552E-EV
    ../../../../../../Drivers/BSP/STM32L552E-EV/: stm32l552e_eval_sd.c stm32l552e_eval_bus.c stm32l552e_eval_io.c stm32l552e_eval.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_ll_sdmmc.c stm32l5xx_hal_mmc_ex.c stm32l5xx_hal_mmc.c stm32l5xx_hal_sd_ex.c stm32l5xx_hal_sd.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_icache.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l5xx.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
