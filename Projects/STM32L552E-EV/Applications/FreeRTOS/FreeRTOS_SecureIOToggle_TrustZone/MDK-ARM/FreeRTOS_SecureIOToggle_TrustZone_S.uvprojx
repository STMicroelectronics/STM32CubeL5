# Keil uVision project FreeRTOS_SecureIOToggle_TrustZone_S.uvprojx, settings and files
target FreeRTOS_SecureIOToggle_TrustZone_S (6120000::V6.12::.\ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.0.9
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: FreeRTOS_SecureIOToggle_TrustZone_S +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L552xx
  c include: ../Secure/Inc;../Secure_nsclib;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/secure;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/non_secure;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32L552E-EV
  asm include: ..\\Secure\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: stm32l552xe_flash_s.sct
  link misc: --import_cmse_lib_out=..\Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ./: startup_stm32l552xx.s
  group Application/User/Secure
    ../Secure/Src/: main.c stm32l5xx_it.c stm32l5xx_hal_msp.c secure_nsc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152_reg.c mfxstm32l152.c
  group Drivers/BSP/STM32L552E-EV
    ../../../../../../Drivers/BSP/STM32L552E-EV/: stm32l552e_eval_bus.c stm32l552e_eval_io.c stm32l552e_eval.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal_exti.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_icache.c stm32l5xx_hal_gtzc.c
  group Drivers/CMSIS
    ../Secure/Src/: system_stm32l5xx_s.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33/secure/: secure_context.c secure_context_port.c secure_heap.c secure_init.c
software components: CMSIS:CORE 4.3.0
